# IAR project STM8_Driver.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207K8 STM8S207K8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x300
  General.GenHeapSize: 0x7F
  ICCSTM8.CCDefines: BOARD_STM8; COMPILER_IAR; NO_FS
  ICCSTM8.CCIncludePath2: D:\Project\Iot_Work\irext\examples\stm8-driver\src; D:\Project\Iot_Work\irext\examples\stm8-driver\src\lib\inc; D:\Project\Iot_Work\irext\examples\stm8-driver\src\irext\include
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STM8_Driver.hex
  ILINK.IlinkOutputFile: templproj.out
  ILINK.IlinkIcfFile: D:\Project\Iot_Work\irext\examples\stm8-driver\src\lnkstm8s207k8.icf
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group (top)
    src/irext/src/: ir_ac_apply.c ir_ac_binary_parse.c ir_ac_build_frame.c ir_ac_control.c ir_ac_parse_forbidden_info.c ir_ac_parse_frame_info.c ir_ac_parse_parameter.c ir_decode.c ir_tv_control.c ir_utils.c
    src/: main.c stm8s_it.c
    src/lib/src/: stm8s_clk.c stm8s_gpio.c stm8s_tim4.c stm8s_uart3.c
